## general/package/factoryinit/Config.in
```kconfig
config BR2_PACKAGE_FACTORYINIT
	bool "factoryinit"
	default y
	help
	  OpenIPC 产线一问一答 UDP 动态服务。
```
